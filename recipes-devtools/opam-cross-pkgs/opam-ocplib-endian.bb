DESCRIPTION = "Optimised functions to read and write int16/32/64 from strings and bigarrays"
SECTION = "devel"
LICENSE = "GPLv2"

DEPENDS += " opam-ocamlbuild opam-cppo"

inherit opam_install

#OPAM_VERBOSE = "1"
