DESCRIPTION = "Functions to manipulate real file (POSIX like) and filename"
SECTION = "devel"
LICENSE = "LGPLv2.1"

inherit opam_install

DEPENDS += " opam-ocamlbuild"

#OPAM_VERBOSE = "1"
