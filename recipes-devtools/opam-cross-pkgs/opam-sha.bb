DESCRIPTION = "Binding to the SHA cryptographic functions"
SECTION = "devel"
LICENSE = "ISC"

inherit opam_install

#OPAM_VERBOSE = "1"
