DESCRIPTION = "A minimal XML parser & printer for OCaml"
SECTION = "devel"
LICENSE = "GPLv2"

inherit opam_install

#OPAM_VERBOSE = "1"
