DESCRIPTION = "Enhanced standard library for OCaml"
SECTION = "devel"
LICENSE = "LGPLv2.1"

inherit opam_install

#OPAM_VERBOSE = "1"
