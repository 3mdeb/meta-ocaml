DESCRIPTION = "TOML (Tom's Obvious Minimal Language) parser"
SECTION = "devel"
LICENSE = "LGPL3"

DEPENDS += " opam-menhir opam-dune"

inherit opam_install

#OPAM_VERBOSE = "1"
