
DEPENDS += " ocaml-cross-${TARGET_ARCH} opam-cross-${TARGET_ARCH} opam-ocamlfind"

OPAM_ROOT = "${TMPDIR}/work-shared/ocaml/opam-root-${TARGET_SYS}"
